# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\APP;..\Driver;..\Driver\core;..\Driver\startup;..\Hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c stm32f10x_it.c stm32f10x_it.h
  group Driver
    ../Driver/: LF_delay.c LF_delay.h LF_gpio.c LF_gpio.h LF_header.h
    ../Driver/core/: core_cm3.c core_cm3.h misc.c misc.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
    ../Driver/startup/: startup_stm32f10x_md.s
